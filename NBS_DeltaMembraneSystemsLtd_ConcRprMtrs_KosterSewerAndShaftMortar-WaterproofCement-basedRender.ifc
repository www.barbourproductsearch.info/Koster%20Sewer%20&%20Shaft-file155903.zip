Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-10-18T11:21:44
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcCovering: Basic Wall:NBS_DeltaMembraneSystemsLtd_ConcreteRepairMortars_KosterSewerAndShaftMortar-WaterproofCement-basedRender, Basic Wall:NBS_DeltaMembraneSystemsLtd_ConcreteRepairMortars_KosterSewerAndShaftMortar-WaterproofCement-basedRender:221873
In: Level 0
Type - Material: NBS_DeltaMembraneSystemsLtd_ConcreteRepairMortars_KosterSewerAndShaftMortar-WaterproofCement-basedRender 0.8 mm
Type - IFC - IfcExportAs: IfcCoveringType
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_20_31_53_15: Concrete repair mortars; Color: n/a; Finish: n/a; Material: n/a; Shape: n/a; Size: n/a; WarrantyDescription: Ten year; CodePerformance: n/a; Constituents: n/a; Description: Waterproof cement based render that is chemically resistant, fast curing restoration mortar for sewers and shafts.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@deltamembranes.com; ModelNumber: n/a; ModelReference: Koster Sewer & Shaft Mortar - Waterproof Cement-based Render; Name: ConcreteRepairMortars_KosterSewerAndShaftMortar-WaterproofCement-basedRender_DeltaMembraneSystemsLtd; NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_DeltaMembraneSystemsLtd_ConcreteRepairMortars_KosterSewerAndShaftMortar-WaterproofCement-basedRender; ManufacturerName: Delta Membrane Systems Ltd; ManufacturerURL: https://www.deltamembranes.com; ProductInformation: https://source.thenbs.com/product/-/7a5b75eb-e65e-44ad-95b3-4a8f406b8622/d90faeaf-0150-4ba1-8c1c-a9cc6d8aaff8; Uniclass2015Code: Pr_20_31_53_15; Uniclass2015Title: Concrete repair mortars; Uniclass2015Version: Products v1.35; Version: 6
Type - NBS_Data - MortarType: Cement based; PerformanceRequirementClass: R1; CountryOfProductManufacture: Germany
Classification: Pr_20_31_53_15 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:NBS_DeltaMembraneSystemsLtd_ConcreteRepairMortars_KosterSewerAndShaftMortar-WaterproofCement-basedRender, Floor:NBS_DeltaMembraneSystemsLtd_ConcreteRepairMortars_KosterSewerAndShaftMortar-WaterproofCement-basedRender:222014
In: Level 0
Type - Material: NBS_DeltaMembraneSystemsLtd_ConcreteRepairMortars_KosterSewerAndShaftMortar-WaterproofCement-basedRender 0.8 mm
Type - IFC - IfcExportAs: IfcCoveringType
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_20_31_53_15: Concrete repair mortars; Color: n/a; Finish: n/a; Material: n/a; Shape: n/a; Size: n/a; WarrantyDescription: Ten year; CodePerformance: n/a; Constituents: n/a; Description: Waterproof cement based render that is chemically resistant, fast curing restoration mortar for sewers and shafts.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@deltamembranes.com; ModelNumber: n/a; ModelReference: Koster Sewer & Shaft Mortar - Waterproof Cement-based Render; Name: ConcreteRepairMortars_KosterSewerAndShaftMortar-WaterproofCement-basedRender_DeltaMembraneSystemsLtd; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_DeltaMembraneSystemsLtd_ConcreteRepairMortars_KosterSewerAndShaftMortar-WaterproofCement-basedRender; ManufacturerName: Delta Membrane Systems Ltd; ManufacturerURL: https://www.deltamembranes.com; ProductInformation: https://source.thenbs.com/product/-/7a5b75eb-e65e-44ad-95b3-4a8f406b8622/d7920dc5-fdf4-4570-a2d7-3dd0ab0bd22e; Uniclass2015Code: Pr_20_31_53_15; Uniclass2015Title: Concrete repair mortars; Uniclass2015Version: Products v1.35; Version: 7
Type - NBS_Data - MortarType: Cement based; PerformanceRequirementClass: R1; CountryOfProductManufacture: Germany
Classification: Pr_20_31_53_15 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
